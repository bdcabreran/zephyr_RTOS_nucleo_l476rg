## build/Kconfig/Kconfig.soc.arch
```kconfig
osource "/home/bayron/zephyrproject/zephyr/soc/$(ARCH)/Kconfig"
osource "/home/bayron/zephyrproject/zephyr/soc/$(ARCH)/*/Kconfig"
```
